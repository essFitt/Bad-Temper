# Repository essFitt/Bad-Temper

File README.md:

This is a remix of the [Temper keyboard](https://github.com/raeedcho/temper). 
The build process and the materials pretty much the same. The reset switch was swapped out for a 6mm tactile button switch. 
To reduce the height of the board, the PCB is not designed to accommodate a base plate. However, I have added a case that is press-fitted and, in my experience, works really well. If printing, you may need to tinker with your tolerances.

## KiCad design pcb/BadTemper.kicad_pcb

Parts:
BT1: Battery_Cell; Battery_pads_reversible
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: D; D_SMD_TH
J2: nice_view; nice_view_jumpers
PWR_SW1: SW_SPDT; power_switch_padreverse
RSW1: SW_PUSH; SW_PUSH_6mm
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18: SW_PUSH; Kailh_socket_PG1350_reversible
U1: nice_nano; ProMicro_jumpers

Connections:
CS: J2.5 (CS), U1.1 (D1/P0.06)
GND: BT1.2 (-), J2.4 (GND), RSW1.2, U1.3 (GND), U1.4 (GND), U1.23 (GND)
MOSI: J2.1 (MOSI), U1.5 (D2/P0.17)
unnamed: BT1.1 (+), PWR_SW1.2 (B)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
SCK: J2.2 (SCK), U1.6 (D3/P0.20)
VCC: J2.3 (VCC), U1.21 (VCC)
col0: SW1.1, SW6.1, SW11.1, U1.20 (D21/P0.31)
col1: SW2.1, SW7.1, SW12.1, U1.19 (D20/P0.29)
col2: SW3.1, SW8.1, SW13.1, SW16.1, U1.18 (D19/P0.02)
col3: SW4.1, SW9.1, SW14.1, SW17.1, U1.17 (D18/P1.15)
col4: SW5.1, SW10.1, SW15.1, SW18.1, U1.16 (D15/P1.13)
reset: RSW1.1, U1.22 (RESET)
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), U1.7 (D4/P0.22)
row1: D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), U1.8 (D5/P0.24)
row2: D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), U1.9 (D6/P1.00)
row3: D16.1 (K), D17.1 (K), D18.1 (K), U1.10 (D7/P0.11)
vbat: PWR_SW1.3 (C), U1.24 (BATTERY+)

Board: 2 copper layers, 119.2 x 90.8 mm, 44 parts (0 on the bottom side), 35 nets.

Other parts of the board:
h5: h5; LEGO_HOLE
h6: h6; LEGO_HOLE
h7: h7; LEGO_HOLE

File pcb/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BT1,Battery_pads_reversible,1,Battery_Cell,
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D2, D3, D4, D5, D6, D7, D8, D9",D_SMD_TH,18,D,
J2,nice_view_jumpers,1,nice_view,
PWR_SW1,power_switch_padreverse,1,SW_SPDT,
RSW1,SW_PUSH_6mm,1,SW_PUSH,
"SW1, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9",Kailh_socket_PG1350_reversible,18,SW_PUSH,
U1,ProMicro_jumpers,1,nice_nano,

## Commit log

2024-09-08 Create placeholder
2024-09-08 Create lib
2024-09-08 Create pt
2024-09-08 Create INFORMATION
2024-09-08 Rename INFORMATION to INFORMATION.md
2024-09-08 Rename INFORMATION.md to INFORMATION
2024-12-01 Case files uploaded
2024-12-01 Updated case information
2024-12-01 Case information added
2024-12-01 Update INFORMATION
